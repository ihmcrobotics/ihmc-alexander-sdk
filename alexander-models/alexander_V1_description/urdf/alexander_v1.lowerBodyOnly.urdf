Commit message: updated torso link weight in urdf

File: alexander-models/alexander_V1_description/urdf/alexander_v1.lowerBodyOnly.urdf (robot description, URDF)
Before this commit: robot Alexander, 23 links, 22 joints
Links:
- link TORSO_LINK: mass 2.13269743 -> 4.352
